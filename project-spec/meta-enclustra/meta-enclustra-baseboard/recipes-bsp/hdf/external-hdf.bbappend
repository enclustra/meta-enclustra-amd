FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

HDF_EXT = "xsa"
HDF_BASE = "file://"
#HDF_PATH = "Enclustra.xsa"
