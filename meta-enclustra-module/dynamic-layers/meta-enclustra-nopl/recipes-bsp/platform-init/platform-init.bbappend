FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
PLATFORM_INIT_DIR = "file://"
